Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-05-23T22:57:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 23 22:57:57 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{A717A719-4046-4EBB-9503-0269C66EE54D}\ifc * Database version: 5507 * Database creation date: Mon May 23 22:57:57 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 23 22:57:57 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 23 22:57:57 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 52372267(2022) Washbasin faucet, 52372267(2022):52372267(2022) Washbasin faucet:48022
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 148.456 mm; NominalHeight: 188.5 mm; NominalWidth: 46.4989 mm
Type - General - Author: BIMStone; BIMObjectName: 52372267(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/05/2022
Type - Green Building Properties - EAN Number: 4057304017179; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.hansa.com/DoC/52372267; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/52372267; Catalog Drawing URL: http://static.hansa.com/catdrw/52372267; Dimension Drawing URL: http://static.hansa.com/dimdrw/52372267; FDV Document URL: http://www.hansa.com/datasheet/52372267/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/52372267; Group: Washbasin faucet; Interactive AR View URL: https://static.hansa.com/AR/52372267; Item Type: Sales item; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands;France;Czech Republic;Slovakia;Italy;Spain; Mobile Product Information URL: http://mpi.hansa.com/52372267; Model: 52372267(2022) Washbasin faucet; Name_en: 52372267(2022) Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 52372267(2022); Product Family: HANSAVANTIS XL; Product Image URL: http://static.hansa.com/image/52372267; Product URL: http://static.hansa.com/52372267; Technical DataSheet URL: http://www.hansa.com/datasheet/52372267/en; Type Name: 52372267(2022) Washbasin faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 114 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 52372267(2022); Features: Single-lever; Finish: Polished; Grade: n/a; Material: brassPlastic; ModelNumber: n/a; ModelReference: 52372267(2022); Name: 52372267(2022) Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x170x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0447621 m2; Volume: 0.00130681 m3
Identity Data - Mark: 20
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 52372267(2022): 52372267(2022) Washbasin faucet; Family and Type: 52372267(2022): 52372267(2022) Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 52372267(2022): 52372267(2022) Washbasin faucet; Type Id: 52372267(2022): 52372267(2022) Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
